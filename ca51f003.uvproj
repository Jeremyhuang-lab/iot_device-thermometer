# Keil uVision project ca51f003.uvproj, settings and files
target CA51F (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51f003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\mcu_sdk
  link misc: REMOVEUNUSED
  group Source Files
    ./source/: main.c uart.c delay.c system_clock.c rgb.c mysystem.c key.c pwm.c myi2c.c oled.c beep.c sht30.c
  group Lib
    ./lib/: STARTUP.A51
  group mcu_sdk
    ./mcu_sdk/: mcu_api.c protocol.c system.c
